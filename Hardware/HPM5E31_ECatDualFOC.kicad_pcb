# Repository LX050724/HPM5E31_ECatDualFOC

File README.md:

# 基于HPM5E31的双路EtherCAT高性能高精度FOC驱动板

仓库使用lfs，不能直接下载zip，jlink版本需要v10以上

## 产品规格：

| 支持电机数   | 2路                                                          |
| ------------ | ------------------------------------------------------------ |
| 动力电源     | 24VDC~60VDC                                                  |
| 额定输出电流 | 20Arms                                                       |
| 峰值输出电流 | 未测试                                                       |
| 急停按钮     | 光耦输入，支持常开式或常闭式接线或外部电源控制<br />支持硬件安全扭矩关断（SOT） |
| 反馈信号     | 差分ABZ<br />差分UVW<br />基于SPI接口的编码器（抗干扰弱）<br />基于高速485接口的编码器如多摩川<br />电机温度NTC |
| 能耗制动     | 可外接制动电阻                                               |
| 抱闸         | 支持，最大电流1A，支持电流测量                               |
| 冷却方式     | 可选的板载散热器和风扇主动散热                               |
| 脉冲方向控制 | 复用ABZ编码器接口可实现PD、UD模式脉冲输入                    |
| 模拟量输入   | 不支持                                                       |
| UART         | 支持一路调试串口                                             |
| RS485        | 硬件支持1路专用，2路与485编码器复用                          |
| CANFD        | 硬件支持2路                                                  |
| EtherCAT     | 硬件支持2端口                                                |
| USB2.0HS     | 支持一路Device TypeB接口                                     |
| 同步信号     | 支持2路TRGM IO，可输入输出PWM同步信号或PPS同步信号等         |
| 存储         | 程序flash 1Mbyte，外置数据qspiflash 128Mbit                  |

## 电源树：

## 硬件架构框图：

## KiCad design Hardware/HPM5E31_ECatDualFOC.kicad_pcb

Parts:
C91, C96, C100, C105: 100nF,50V; C_0603_1608Metric
C198: 22uF,25V; C_0805_2012Metric
C199, C200: 100nF,16V; C_0402_1005Metric
J15: HR911205C
J16: Conn_01x02; JST_PH_B2B-PH-K_1x02_P2.00mm_Vertical
R21: 0R,1%; R_0402_1005Metric
R100, R102, R105, R110: 4.7K,1%; R_0402_1005Metric
R101, R103, R109, R111: 330R,1%; R_0402_1005Metric
R112: 1M,1%; R_0805_2012Metric
R186: 10K,1%; R_0402_1005Metric
U34, U38, U46, U47: M3; MountingHole_3.2mm_M3_Pad_Via
U60: 74LVC1G08; SOT-353_SC-70-5
U62: MT9700; SOT-23-5

Connections:
+3.3V: J15.A12, J15.B9, J15.B12, R102.1, R105.1, R110.1; also elsewhere on the board
+3.3_2: C199.1, U60.5 (VCC); also elsewhere on the board
+5V: C200.2, U62.5 (VIN); also elsewhere on the board
/BRAKE_RES/BRAKE_RES_EN: U60.4; also elsewhere on the board
/ETHERNET_PHY_P0/RD_N: J15.A6 (RD-); also elsewhere on the board
/ETHERNET_PHY_P0/RD_P: J15.A3 (RD+); also elsewhere on the board
/ETHERNET_PHY_P0/TD_N: J15.A2 (TD-); also elsewhere on the board
/ETHERNET_PHY_P0/TD_P: J15.A1 (TD+); also elsewhere on the board
/ETHERNET_PHY_P2/RD_N: J15.B6 (RD-); also elsewhere on the board
/ETHERNET_PHY_P2/RD_P: J15.B3 (RD+); also elsewhere on the board
/ETHERNET_PHY_P2/TD_N: J15.B2 (TD-); also elsewhere on the board
/ETHERNET_PHY_P2/TD_P: J15.B1 (TD+); also elsewhere on the board
/P0_LED0: R102.2, R103.2; also elsewhere on the board
/P0_LED1: J15.A9, R100.1; also elsewhere on the board
/P2_LED0: R105.2, R109.2; also elsewhere on the board
/P2_LED1: R110.2, R111.2; also elsewhere on the board
/nBREAK: R21.2, U60.1; also elsewhere on the board
Earth: J15.A8, J15.SH1, R112.2
Earth2: J15.B8, J15.SH2
Earth3: J15.SH3
GND: C91.2, C96.2, C100.2, C105.2, C198.2, C199.2, C200.1, J16.2, R100.2, R101.2, R112.1, R186.1, U60.3 (GND), U62.2 (GND); also elsewhere on the board
unnamed: J15.A10, R101.1
unnamed: J15.A11, R103.1
unnamed: J15.B10, R111.1
unnamed: J15.B11, R109.1
unnamed: C91.1, J15.A5 (RCT)
unnamed: C96.1, J15.A4 (TCT)
unnamed: C105.1, J15.B5 (RCT)
unnamed: C100.1, J15.B4 (TCT)
unnamed: C198.1, J16.1, U62.1 (VOUT)
unnamed: R186.2, U62.3 (SET)
PC10: R21.1; also elsewhere on the board
PF19: U60.2; also elsewhere on the board
PF24: U62.4 (EN); also elsewhere on the board

Notes on the sheet:
PHY2_ADDR=11b
风扇控制
PHY0_ADDR=01b

Parts:
C89, C90, C93: 100nF,16V; C_0402_1005Metric
C92: 10uF,10V; C_0402_1005Metric
C94: 10uF,10V; C_0402_1005Metric; not fitted
C95, C97: 100nF,16V; C_0402_1005Metric; not fitted
R99, R104: 33R,1%; R_0201_0603Metric
R106: 0R,1%; R_0402_1005Metric; not fitted
R107: 2.49K,1%; R_0402_1005Metric
R114: 0R,1%; R_0201_0603Metric
U45: JL1111-N032I; QFN-32-1EP_5x5mm_P0.5mm_EP3.1x3.1mm

Connections:
+3.3V: C89.1, C90.1, C97.1, R106.2, U45.7 (AVDD33), U45.14 (DVDDIO); also elsewhere on the board
/ETHERNET_PHY_P0/MII.LINK: R114.1; also elsewhere on the board
/ETHERNET_PHY_P0/MII.RXC: R104.1; also elsewhere on the board
/ETHERNET_PHY_P0/MII.RXD0: U45.9 (RXD0); also elsewhere on the board
/ETHERNET_PHY_P0/MII.RXD1: U45.10 (RXD1); also elsewhere on the board
/ETHERNET_PHY_P0/MII.RXD2: U45.11 (RXD2/INT_N); also elsewhere on the board
/ETHERNET_PHY_P0/MII.RXD3: U45.12 (RXD3); also elsewhere on the board
/ETHERNET_PHY_P0/MII.RX_DV: U45.8 (RX_DV); also elsewhere on the board
/ETHERNET_PHY_P0/MII.RX_ER: U45.28 (RX_ER); also elsewhere on the board
/ETHERNET_PHY_P0/MII.TXC: R99.1; also elsewhere on the board
/ETHERNET_PHY_P0/MII.TXD0: U45.16 (TXD0); also elsewhere on the board
/ETHERNET_PHY_P0/MII.TXD1: U45.17 (TXD1); also elsewhere on the board
/ETHERNET_PHY_P0/MII.TXD2: U45.18 (TXD2); also elsewhere on the board
/ETHERNET_PHY_P0/MII.TXD3: U45.19 (TXD3); also elsewhere on the board
/ETHERNET_PHY_P0/MII.TXEN: U45.20 (TX_EN); also elsewhere on the board
/ETHERNET_PHY_P0/RD_N: U45.6 (RD_N); also elsewhere on the board
/ETHERNET_PHY_P0/RD_P: U45.5 (RD_P); also elsewhere on the board
/ETHERNET_PHY_P0/TD_N: U45.4 (TD_N); also elsewhere on the board
/ETHERNET_PHY_P0/TD_P: U45.3 (TD_P); also elsewhere on the board
/ETHERNET_PHY_P2/MII.MDC: U45.22 (MDC); also elsewhere on the board
/ETHERNET_PHY_P2/MII.MDIO: U45.23 (MDIO); also elsewhere on the board
/ETHERNET_PHY_P2/MII.REFCLK: U45.31 (XI); also elsewhere on the board
/ETHERNET_PHY_P2/MII.RST: U45.21 (RESET_N); also elsewhere on the board
/P0_LED0: U45.24 (LED0); also elsewhere on the board
/P0_LED1: R114.2, U45.25 (LED1); also elsewhere on the board
GND: C89.2, C90.2, C92.2, C93.2, C94.2, C95.2, C97.2, R107.2, U45.33 (GND); also elsewhere on the board
unnamed: C92.1, C93.1, U45.29 (DVDD1V2)
unnamed: R106.1, U45.30 (EN_DLDO)
unnamed: R107.1, U45.1 (RBIAS)
unnamed: C94.1, C95.1, U45.2 (REFCLK_SEL)
unnamed: R104.2, U45.13 (RXC)
unnamed: R99.2, U45.15 (TXC)

Parts of its further copies:
C98, C99, C102: 100nF,16V; C_0402_1005Metric
C101: 10uF,10V; C_0402_1005Metric
C103: 10uF,10V; C_0402_1005Metric; not fitted
C104, C106: 100nF,16V; C_0402_1005Metric; not fitted
R108, R113: 33R,1%; R_0201_0603Metric
R115: 0R,1%; R_0402_1005Metric; not fitted
R116: 2.49K,1%; R_0402_1005Metric
R183: 0R,1%; R_0201_0603Metric
U48: JL1111-N032I; QFN-32-1EP_5x5mm_P0.5mm_EP3.1x3.1mm

Connections of its further copies:
+3.3V: C98.1, C99.1, C106.1, R115.2, U48.7 (AVDD33), U48.14 (DVDDIO); also elsewhere on the board
/ETHERNET_PHY_P2/MII.LINK: R183.1; also elsewhere on the board
/ETHERNET_PHY_P2/MII.MDC: U48.22 (MDC); also elsewhere on the board
/ETHERNET_PHY_P2/MII.MDIO: U48.23 (MDIO); also elsewhere on the board
/ETHERNET_PHY_P2/MII.REFCLK: U48.31 (XI); also elsewhere on the board
/ETHERNET_PHY_P2/MII.RST: U48.21 (RESET_N); also elsewhere on the board
/ETHERNET_PHY_P2/MII.RXC: R113.1; also elsewhere on the board
/ETHERNET_PHY_P2/MII.RXD0: U48.9 (RXD0); also elsewhere on the board
/ETHERNET_PHY_P2/MII.RXD1: U48.10 (RXD1); also elsewhere on the board
/ETHERNET_PHY_P2/MII.RXD2: U48.11 (RXD2/INT_N); also elsewhere on the board
/ETHERNET_PHY_P2/MII.RXD3: U48.12 (RXD3); also elsewhere on the board
/ETHERNET_PHY_P2/MII.RX_DV: U48.8 (RX_DV); also elsewhere on the board
/ETHERNET_PHY_P2/MII.RX_ER: U48.28 (RX_ER); also elsewhere on the board
/ETHERNET_PHY_P2/MII.TXC: R108.1; also elsewhere on the board
/ETHERNET_PHY_P2/MII.TXD0: U48.16 (TXD0); also elsewhere on the board
/ETHERNET_PHY_P2/MII.TXD1: U48.17 (TXD1); also elsewhere on the board
/ETHERNET_PHY_P2/MII.TXD2: U48.18 (TXD2); also elsewhere on the board
/ETHERNET_PHY_P2/MII.TXD3: U48.19 (TXD3); also elsewhere on the board
/ETHERNET_PHY_P2/MII.TXEN: U48.20 (TX_EN); also elsewhere on the board
/ETHERNET_PHY_P2/RD_N: U48.6 (RD_N); also elsewhere on the board
/ETHERNET_PHY_P2/RD_P: U48.5 (RD_P); also elsewhere on the board
/ETHERNET_PHY_P2/TD_N: U48.4 (TD_N); also elsewhere on the board
/ETHERNET_PHY_P2/TD_P: U48.3 (TD_P); also elsewhere on the board
/P2_LED0: U48.24 (LED0); also elsewhere on the board
/P2_LED1: R183.2, U48.25 (LED1); also elsewhere on the board
GND: C98.2, C99.2, C101.2, C102.2, C103.2, C104.2, C106.2, R116.2, U48.33 (GND); also elsewhere on the board
unnamed: C101.1, C102.1, U48.29 (DVDD1V2)
unnamed: R115.1, U48.30 (EN_DLDO)
unnamed: R116.1, U48.1 (RBIAS)
unnamed: C103.1, C104.1, U48.2 (REFCLK_SEL)
unnamed: R113.2, U48.13 (RXC)
unnamed: R108.2, U48.15 (TXC)

Notes on the sheet:
Mount if RTL8201/YT8522
Mount if RTL8201/YT8522/YT8512

Parts:
C107: 100nF,16V; C_0402_1005Metric
J17: WAFER-GH1.25-4PWB; JST_GH_SM04B-GHS-TB_1x04-1MP_P1.25mm_Horizontal
L5: SDCW2012-2-102TF; L_CommonModeChoke_Coilcraft_0805USB
R117, R119: 10K,1%; R_0402_1005Metric
R118: 120R,1%; R_0603_1608Metric
U49: SP3485EN-L/TR; SOIC-8_3.9x4.9mm_P1.27mm

Connections:
+3.3V: C107.1, R117.2, U49.8 (VCC); also elsewhere on the board
/ENCODER_CONN_A/ENC_PWR: J17.1; also elsewhere on the board
/HPM5E31_TOP/RS485_4.DE: U49.2 (~RE), U49.3 (DE); also elsewhere on the board
/HPM5E31_TOP/RS485_4.DI: U49.4 (DI); also elsewhere on the board
/HPM5E31_TOP/RS485_4.RO: U49.1 (RO); also elsewhere on the board
/SP485_GROUP_1/485+: J17.2, L5.2
/SP485_GROUP_1/485-: J17.3, L5.3
GND: C107.2, J17.4, J17.MP (MountPin), R119.1, U49.5 (GND); also elsewhere on the board
unnamed: L5.1, R117.1, R118.2, U49.6 (A)
unnamed: L5.4, R118.1, R119.2, U49.7 (B)

Parts of its further copies:
C108, C109: 100nF,16V; C_0402_1005Metric
J18, J19: WAFER-GH1.25-4PWB; JST_GH_SM04B-GHS-TB_1x04-1MP_P1.25mm_Horizontal
L6, L7: SDCW2012-2-102TF; L_CommonModeChoke_Coilcraft_0805USB
R120, R122, R123, R125: 10K,1%; R_0402_1005Metric
R121, R124: 120R,1%; R_0603_1608Metric
U50, U51: SP3485EN-L/TR; SOIC-8_3.9x4.9mm_P1.27mm

Connections of its further copies:
+3.3V: C108.1, C109.1, R120.2, R123.2, U50.8 (VCC), U51.8 (VCC); also elsewhere on the board
+5V: J19.1; also elsewhere on the board
/ENCODER_CONN_B/ENC_PWR: J18.1; also elsewhere on the board
/HPM5E31_TOP/RS485_3.DE: U50.2 (~RE), U50.3 (DE); also elsewhere on the board
/HPM5E31_TOP/RS485_3.DI: U50.4 (DI); also elsewhere on the board
/HPM5E31_TOP/RS485_3.RO: U50.1 (RO); also elsewhere on the board
/HPM5E31_TOP/RS485_6.DE: U51.2 (~RE), U51.3 (DE); also elsewhere on the board
/HPM5E31_TOP/RS485_6.DI: U51.4 (DI); also elsewhere on the board
/HPM5E31_TOP/RS485_6.RO: U51.1 (RO); also elsewhere on the board
/SP485_GROUP_2/485+: J18.2, L6.2
/SP485_GROUP_2/485-: J18.3, L6.3
/SP485_GROUP_3/485+: J19.2, L7.2
/SP485_GROUP_3/485-: J19.3, L7.3
GND: C108.2, C109.2, J18.4, J18.MP (MountPin), J19.4, J19.MP (MountPin), R122.1, R125.1, U50.5 (GND), U51.5 (GND); also elsewhere on the board
unnamed: L6.1, R120.1, R121.2, U50.6 (A)
unnamed: L6.4, R121.1, R122.2, U50.7 (B)
unnamed: L7.1, R123.1, R124.2, U51.6 (A)
unnamed: L7.4, R124.1, R125.2, U51.7 (B)

Parts:
C31, C33, C36, C38, C41, C43: 1uF,25V; C_0402_1005Metric
C32, C37, C42: 1uF,100V; C_1206_3216Metric
C34, C39, C44, C46, C156, C158, C160, C161, C164, C165: 2.2nF,50V; C_0402_1005Metric
C35, C40, C45, C47, C152: 100nF,16V; C_0402_1005Metric
C168, C170, C172, C192, C194, C196: 1nF,100V; C_0603_1608Metric; not fitted
C174, C176, C178, C180, C181, C182, C186, C187, C188: 1nF,50V; C_0201_0603Metric
D14, D16, D17, D19, D20, D22: 1N5819WS; D_SOD-323
J7, J8, J9: YZ-1
NT1, NT2, NT3, NT4, NT5, NT6, NT7, NT8: NetTie_2; NetTie_SMD_5mil
Q1, Q2, Q3, Q4, Q5, Q6: CSD19532Q5B; PQFN-8-EP_6x5mm_P1.27mm_Generic
R28, R31, R33, R36, R38, R41: 10R,1%; R_0402_1005Metric
R29, R34, R39, R43: 2mR,1%,3W; R_2512_6332Metric
R30, R35, R40, R42: 33R,1%; R_0402_1005Metric
R140, R142, R144, R177, R179, R181: 4.7R,1%; R_0603_1608Metric; not fitted
R147, R149, R151, R153, R154, R155, R159, R160, R161: 33R,1%; R_0201_0603Metric
R165, R167, R169, R170, R173, R174: 15R,1%; R_0402_1005Metric
U12, U14, U16: UCC27282DRCR; VSON-10-1EP_3x3mm_P0.5mm_EP1.65x2.4mm
U13, U15, U17, U19: INA240A1PWR; TSSOP-8_4.4x3mm_P0.65mm
U18: 74LVC1G08; SOT-353_SC-70-5

Connections:
+3.3_2: C152.2, U18.5 (VCC); also elsewhere on the board
+10V: C31.1, C36.1, C41.1, U12.1 (VDD), U14.1 (VDD), U16.1 (VDD); also elsewhere on the board
/HPM5E31_TOP/DRIVER_B.CUR0: C34.1, R30.2; also elsewhere on the board
/HPM5E31_TOP/DRIVER_B.CUR1: C39.1, R35.2; also elsewhere on the board
/HPM5E31_TOP/DRIVER_B.CUR2: C44.1, R40.2; also elsewhere on the board
/HPM5E31_TOP/DRIVER_B.CUR3: C46.1, R42.2; also elsewhere on the board
/HPM5E31_TOP/DRIVER_B.EN: U18.1; also elsewhere on the board
/HPM5E31_TOP/DRIVER_B.HI0: R147.1; also elsewhere on the board
/HPM5E31_TOP/DRIVER_B.HI1: R159.1; also elsewhere on the board
/HPM5E31_TOP/DRIVER_B.HI2: R153.1; also elsewhere on the board
/HPM5E31_TOP/DRIVER_B.LI0: R149.1; also elsewhere on the board
/HPM5E31_TOP/DRIVER_B.LI1: R160.1; also elsewhere on the board
/HPM5E31_TOP/DRIVER_B.LI2: R154.1; also elsewhere on the board
/INVERTER_BRIDGE_B/C0_N: NT2.2, U13.3 (IN-)
/INVERTER_BRIDGE_B/C0_P: NT1.2, U13.2 (IN+)
/INVERTER_BRIDGE_B/C1_N: NT4.2, U15.3 (IN-)
/INVERTER_BRIDGE_B/C1_P: NT3.2, U15.2 (IN+)
/INVERTER_BRIDGE_B/C2_N: NT6.2, U17.3 (IN-)
/INVERTER_BRIDGE_B/C2_P: NT5.2, U17.2 (IN+)
/INVERTER_BRIDGE_B/C3_N: NT8.2, U19.3 (IN-)
/INVERTER_BRIDGE_B/C3_P: NT7.2, U19.2 (IN+)
/INVERTER_BRIDGE_B/EN: R151.1, R155.1, R161.1, U18.4
/INVERTER_BRIDGE_B/M_A: J7.1, NT1.1, R29.2
/INVERTER_BRIDGE_B/M_B: J8.1, NT3.1, R34.2
/INVERTER_BRIDGE_B/M_C: J9.1, NT5.1, R39.2
/INVERTER_BRIDGE_B/VBUS': C32.1, C37.1, C42.1, C192.1, C194.1, C196.1, NT8.1, Q1.1 (D), Q3.1 (D), Q5.1 (D), R43.1
/nBREAK: U18.2; also elsewhere on the board
GND: C152.1, U18.3 (GND); also elsewhere on the board
GNDA: C34.2, C35.2, C39.2, C40.2, C44.2, C45.2, C46.2, C47.2, U13.4 (GND), U13.7 (REF1), U15.4 (GND), U15.7 (REF1), U17.4 (GND), U17.7 (REF1), U19.4 (GND), U19.7 (REF1); also elsewhere on the board
GNDPWR: C31.2, C32.2, C36.2, C37.2, C41.2, C42.2, C158.2, C161.2, C165.2, C168.2, C170.2, C172.2, C174.2, C176.2, C178.2, C180.2, C181.2, C182.2, C186.2, C187.2, C188.2, Q2.3 (S), Q4.3 (S), Q6.3 (S), U12.9 (VSS), U12.11 (PAD), U14.9 (VSS), U14.11 (PAD), U16.9 (VSS), U16.11 (PAD); also elsewhere on the board
unnamed: C168.1, R140.1
unnamed: C170.1, R142.1
unnamed: C172.1, R144.1
unnamed: C192.2, R177.2
unnamed: C194.2, R179.2
unnamed: C196.2, R181.2
unnamed: C156.1, D14.2 (A), Q1.2 (G), R28.2
unnamed: D14.1 (K), R173.2
unnamed: C158.1, D16.2 (A), Q2.2 (G), R31.2
unnamed: D16.1 (K), R174.2
unnamed: C160.1, D17.2 (A), Q3.2 (G), R33.2
unnamed: D17.1 (K), R165.2
unnamed: C161.1, D19.2 (A), Q4.2 (G), R36.2
unnamed: D19.1 (K), R167.2
unnamed: C164.1, D20.2 (A), Q5.2 (G), R38.2
unnamed: D20.1 (K), R169.2
unnamed: C165.1, D22.2 (A), Q6.2 (G), R41.2
unnamed: D22.1 (K), R170.2
unnamed: C33.2, C156.2, NT2.1, Q1.3 (S), Q2.1 (D), R29.1, R144.2, R181.1, U12.5 (HS)
unnamed: C38.2, C160.2, NT4.1, Q3.3 (S), Q4.1 (D), R34.1, R140.2, R179.1, U14.5 (HS)
unnamed: C43.2, C164.2, NT6.1, Q5.3 (S), Q6.1 (D), R39.1, R142.2, R177.1, U16.5 (HS)
unnamed: C178.1, R151.2, U12.6 (EN)
unnamed: C33.1, U12.3 (HB)
unnamed: C174.1, R147.2, U12.7 (HI)
unnamed: R28.1, R173.1, U12.4 (HO)
unnamed: C176.1, R149.2, U12.8 (LI)
unnamed: R31.1, R174.1, U12.10 (LO)
unnamed: R30.1, U13.8 (OUT)
unnamed: C186.1, R161.2, U14.6 (EN)
unnamed: C38.1, U14.3 (HB)
unnamed: C188.1, R159.2, U14.7 (HI)
unnamed: R33.1, R165.1, U14.4 (HO)
unnamed: C187.1, R160.2, U14.8 (LI)
unnamed: R36.1, R167.1, U14.10 (LO)
unnamed: R35.1, U15.8 (OUT)
unnamed: C180.1, R155.2, U16.6 (EN)
unnamed: C43.1, U16.3 (HB)
unnamed: C182.1, R153.2, U16.7 (HI)
unnamed: R38.1, R169.1, U16.4 (HO)
unnamed: C181.1, R154.2, U16.8 (LI)
unnamed: R41.1, R170.1, U16.10 (LO)
unnamed: R40.1, U17.8 (OUT)
unnamed: R42.1, U19.8 (OUT)
VBUS: NT7.1, R43.2; also elsewhere on the board
VDDA: C35.1, C40.1, C45.1, C47.1, U13.5 (VS), U15.5 (VS), U17.5 (VS), U19.5 (VS); also elsewhere on the board
VREF: U13.6 (REF2), U15.6 (REF2), U17.6 (REF2), U19.6 (REF2); also elsewhere on the board

Parts of its further copies:
C48, C50, C53, C55, C58, C60: 1uF,25V; C_0402_1005Metric
C49, C54, C59: 1uF,100V; C_1206_3216Metric
C51, C56, C61, C63, C157, C159, C162, C163, C166, C167: 2.2nF,50V; C_0402_1005Metric
C52, C57, C62, C64, C153: 100nF,16V; C_0402_1005Metric
C169, C171, C173, C193, C195, C197: 1nF,100V; C_0603_1608Metric; not fitted
C175, C177, C179, C183, C184, C185, C189, C190, C191: 1nF,50V; C_0201_0603Metric
D23, D25, D26, D28, D29, D31: 1N5819WS; D_SOD-323
J10, J11, J12: YZ-1
NT9, NT10, NT11, NT12, NT13, NT14, NT15, NT16: NetTie_2; NetTie_SMD_5mil
Q7, Q8, Q9, Q10, Q11, Q12: CSD19532Q5B; PQFN-8-EP_6x5mm_P1.27mm_Generic
R45, R48, R50, R53, R55, R58: 10R,1%; R_0402_1005Metric
R46, R51, R56, R60: 2mR,1%,3W; R_2512_6332Metric
R47, R52, R57, R59: 33R,1%; R_0402_1005Metric
R141, R143, R145, R178, R180, R182: 4.7R,1%; R_0603_1608Metric; not fitted
R148, R150, R152, R156, R157, R158, R162, R163, R164: 33R,1%; R_0201_0603Metric
R166, R168, R171, R172, R175, R176: 15R,1%; R_0402_1005Metric
U20, U22, U24: UCC27282DRCR; VSON-10-1EP_3x3mm_P0.5mm_EP1.65x2.4mm
U21, U23, U25, U27: INA240A1PWR; TSSOP-8_4.4x3mm_P0.65mm
U26: 74LVC1G08; SOT-353_SC-70-5

Connections of its further copies:
+3.3_2: C153.2, U26.5 (VCC); also elsewhere on the board
+10V: C48.1, C53.1, C58.1, U20.1 (VDD), U22.1 (VDD), U24.1 (VDD); also elsewhere on the board
/HPM5E31_TOP/DRIVER_A.CUR0: C51.1, R47.2; also elsewhere on the board
/HPM5E31_TOP/DRIVER_A.CUR1: C56.1, R52.2; also elsewhere on the board
/HPM5E31_TOP/DRIVER_A.CUR2: C61.1, R57.2; also elsewhere on the board
/HPM5E31_TOP/DRIVER_A.CUR3: C63.1, R59.2; also elsewhere on the board
/HPM5E31_TOP/DRIVER_A.EN: U26.1; also elsewhere on the board
/HPM5E31_TOP/DRIVER_A.HI0: R148.1; also elsewhere on the board
/HPM5E31_TOP/DRIVER_A.HI1: R162.1; also elsewhere on the board
/HPM5E31_TOP/DRIVER_A.HI2: R156.1; also elsewhere on the board
/HPM5E31_TOP/DRIVER_A.LI0: R150.1; also elsewhere on the board
/HPM5E31_TOP/DRIVER_A.LI1: R163.1; also elsewhere on the board
/HPM5E31_TOP/DRIVER_A.LI2: R157.1; also elsewhere on the board
/INVERTER_BRIDGE_A/C0_N: NT10.2, U21.3 (IN-)
/INVERTER_BRIDGE_A/C0_P: NT9.2, U21.2 (IN+)
/INVERTER_BRIDGE_A/C1_N: NT12.2, U23.3 (IN-)
/INVERTER_BRIDGE_A/C1_P: NT11.2, U23.2 (IN+)
/INVERTER_BRIDGE_A/C2_N: NT14.2, U25.3 (IN-)
/INVERTER_BRIDGE_A/C2_P: NT13.2, U25.2 (IN+)
/INVERTER_BRIDGE_A/C3_N: NT16.2, U27.3 (IN-)
/INVERTER_BRIDGE_A/C3_P: NT15.2, U27.2 (IN+)
/INVERTER_BRIDGE_A/EN: R152.1, R158.1, R164.1, U26.4
/INVERTER_BRIDGE_A/M_A: J10.1, NT9.1, R46.2
/INVERTER_BRIDGE_A/M_B: J11.1, NT11.1, R51.2
/INVERTER_BRIDGE_A/M_C: J12.1, NT13.1, R56.2
/INVERTER_BRIDGE_A/VBUS': C49.1, C54.1, C59.1, C193.1, C195.1, C197.1, NT16.1, Q7.1 (D), Q9.1 (D), Q11.1 (D), R60.1
/nBREAK: U26.2; also elsewhere on the board
GND: C153.1, U26.3 (GND); also elsewhere on the board
GNDA: C51.2, C52.2, C56.2, C57.2, C61.2, C62.2, C63.2, C64.2, U21.4 (GND), U21.7 (REF1), U23.4 (GND), U23.7 (REF1), U25.4 (GND), U25.7 (REF1), U27.4 (GND), U27.7 (REF1); also elsewhere on the board
GNDPWR: C48.2, C49.2, C53.2, C54.2, C58.2, C59.2, C159.2, C163.2, C167.2, C169.2, C171.2, C173.2, C175.2, C177.2, C179.2, C183.2, C184.2, C185.2, C189.2, C190.2, C191.2, Q8.3 (S), Q10.3 (S), Q12.3 (S), U20.9 (VSS), U20.11 (PAD), U22.9 (VSS), U22.11 (PAD), U24.9 (VSS), U24.11 (PAD); also elsewhere on the board
unnamed: C169.1, R141.1
unnamed: C171.1, R143.1
unnamed: C173.1, R145.1
unnamed: C193.2, R178.2
unnamed: C195.2, R180.2
unnamed: C197.2, R182.2
unnamed: C157.1, D23.2 (A), Q7.2 (G), R45.2
unnamed: D23.1 (K), R175.2
unnamed: C159.1, D25.2 (A), Q8.2 (G), R48.2
unnamed: D25.1 (K), R176.2
unnamed: C162.1, D26.2 (A), Q9.2 (G), R50.2
unnamed: D26.1 (K), R166.2
unnamed: C163.1, D28.2 (A), Q10.2 (G), R53.2
unnamed: D28.1 (K), R168.2
unnamed: C166.1, D29.2 (A), Q11.2 (G), R55.2
unnamed: D29.1 (K), R171.2
unnamed: C167.1, D31.2 (A), Q12.2 (G), R58.2
unnamed: D31.1 (K), R172.2
unnamed: C50.2, C157.2, NT10.1, Q7.3 (S), Q8.1 (D), R46.1, R145.2, R182.1, U20.5 (HS)
unnamed: C55.2, C162.2, NT12.1, Q9.3 (S), Q10.1 (D), R51.1, R141.2, R180.1, U22.5 (HS)
unnamed: C60.2, C166.2, NT14.1, Q11.3 (S), Q12.1 (D), R56.1, R143.2, R178.1, U24.5 (HS)
unnamed: C179.1, R152.2, U20.6 (EN)
unnamed: C50.1, U20.3 (HB)
unnamed: C175.1, R148.2, U20.7 (HI)
unnamed: R45.1, R175.1, U20.4 (HO)
unnamed: C177.1, R150.2, U20.8 (LI)
unnamed: R48.1, R176.1, U20.10 (LO)
unnamed: R47.1, U21.8 (OUT)
unnamed: C189.1, R164.2, U22.6 (EN)
unnamed: C55.1, U22.3 (HB)
unnamed: C191.1, R162.2, U22.7 (HI)
unnamed: R50.1, R166.1, U22.4 (HO)
unnamed: C190.1, R163.2, U22.8 (LI)
unnamed: R53.1, R168.1, U22.10 (LO)
unnamed: R52.1, U23.8 (OUT)
unnamed: C183.1, R158.2, U24.6 (EN)
unnamed: C60.1, U24.3 (HB)
unnamed: C185.1, R156.2, U24.7 (HI)
unnamed: R55.1, R171.1, U24.4 (HO)
unnamed: C184.1, R157.2, U24.8 (LI)
unnamed: R58.1, R172.1, U24.10 (LO)
unnamed: R57.1, U25.8 (OUT)
unnamed: R59.1, U27.8 (OUT)
VBUS: NT15.1, R60.2; also elsewhere on the board
VDDA: C52.1, C57.1, C62.1, C64.1, U21.5 (VS), U23.5 (VS), U25.5 (VS), U27.5 (VS); also elsewhere on the board
VREF: U21.6 (REF2), U23.6 (REF2), U25.6 (REF2), U27.6 (REF2); also elsewhere on the board

Notes on the sheet:
硬件STO
