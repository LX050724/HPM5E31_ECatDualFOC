# Repository LX050724/HPM5E31_ECatDualFOC (continued)

## KiCad design Hardware/HPM5E31_ECatDualFOC.kicad_pcb (continued)

Parts:
C79, C81, C82, C83, C145, C147: 100nF,16V; C_0402_1005Metric
C80: 1uF,25V; C_0402_1005Metric
D39: RCLAMP0524P; Diodes_UDFN-10_1.0x2.5mm_P0.5mm
J13: PHB2.0-02-20PWZ
NT21: NetTie_2; NetTie_SMD_5mil
R79, R80, R81, R82, R83, R84: 100R,1%,250mW; R_0603_1608Metric
R85: 1K,1%; R_0402_1005Metric
R86, R88: 10K,1%; R_0402_1005Metric
TP1, TP3, TP4, TP6, TP8, TP10, TP12, TP14, TP16, TP18: test_point_0.5mm
U39, U40: MS2575T; TSSOP-16_4.4x5mm_P0.65mm
U41: TXB0104RUTR; UQFN-12_1.7x2_Pitch0.4mm
U56: MT9700; SOT-23-5

Connections:
+3.3V: C79.1, C81.1, C82.1, R85.1, U39.4 (EN), U39.16 (VCC), U40.4 (EN), U40.16 (VCC), U41.1 (VCCA), U41.12 (OE); also elsewhere on the board
+5V: C83.1, C145.1, R88.2, U41.11 (VCCB), U56.5 (VIN); also elsewhere on the board
/ENCODER_CONN_A/A_N: J13.2, R79.1, U39.1 (1B)
/ENCODER_CONN_A/A_P: J13.1, R79.2, U39.2 (1A)
/ENCODER_CONN_A/B_N: J13.4, R80.1, U39.7 (2B)
/ENCODER_CONN_A/B_P: J13.3, R80.2, U39.6 (2A)
/ENCODER_CONN_A/ENC.A: TP14.1, U39.3 (1Y); also elsewhere on the board
/ENCODER_CONN_A/ENC.B: TP16.1, U39.5 (2Y); also elsewhere on the board
/ENCODER_CONN_A/ENC.CLK: TP3.1, U41.5 (A4); also elsewhere on the board
/ENCODER_CONN_A/ENC.CS: TP4.1, U41.3 (A2); also elsewhere on the board
/ENCODER_CONN_A/ENC.MISO: TP6.1, U41.2 (A1); also elsewhere on the board
/ENCODER_CONN_A/ENC.MOSI: TP1.1, U41.4 (A3); also elsewhere on the board
/ENCODER_CONN_A/ENC.PWR: U56.4 (EN); also elsewhere on the board
/ENCODER_CONN_A/ENC.U: TP8.1, U40.3 (1Y); also elsewhere on the board
/ENCODER_CONN_A/ENC.V: TP10.1, U40.5 (2Y); also elsewhere on the board
/ENCODER_CONN_A/ENC.W: TP12.1, U40.11 (3Y); also elsewhere on the board
/ENCODER_CONN_A/ENC.Z: TP18.1, U39.11 (3Y); also elsewhere on the board
/ENCODER_CONN_A/ENC_PWR: C147.2, J13.19, U56.1 (VOUT); also elsewhere on the board
/ENCODER_CONN_A/ENC_SPI_MISO: D39.1 (IO1), D39.10 (NC), J13.10, R88.1, U41.10 (B1)
/ENCODER_CONN_A/ENC_SPI_MOSI: D39.4 (IO3), D39.7 (NC), J13.8, U41.8 (B3)
/ENCODER_CONN_A/ENC_SPI_NSS: D39.2 (IO2), D39.9 (NC), J13.9, U41.9 (B2)
/ENCODER_CONN_A/ENC_SPI_SCK: D39.5 (IO4), D39.6 (NC), J13.7, U41.7 (B4)
/ENCODER_CONN_A/HALL_U_N: J13.14, R82.1, U40.1 (1B)
/ENCODER_CONN_A/HALL_U_P: J13.13, R82.2, U40.2 (1A)
/ENCODER_CONN_A/HALL_V_N: J13.16, R83.1, U40.7 (2B)
/ENCODER_CONN_A/HALL_V_P: J13.15, R83.2, U40.6 (2A)
/ENCODER_CONN_A/HALL_W_N: J13.18, R84.1, U40.9 (3B)
/ENCODER_CONN_A/HALL_W_P: J13.17, R84.2, U40.10 (3A)
/ENCODER_CONN_A/MOTOT_TMP_N: C80.2, J13.12, NT21.2
/ENCODER_CONN_A/Z_N: J13.6, R81.1, U39.9 (3B)
/ENCODER_CONN_A/Z_P: J13.5, R81.2, U39.10 (3A)
/MA_TEMP: C80.1, J13.11, R85.2; also elsewhere on the board
GND: C79.2, C81.2, C82.2, C83.2, C145.2, C147.1, D39.3 (GND), D39.8 (NC), J13.20, NT21.1, R86.1, U39.8 (GND), U39.12 (~EN), U40.8 (GND), U40.12 (~EN), U41.6 (GND), U56.2 (GND); also elsewhere on the board
unnamed: R86.2, U56.3 (SET)

Parts of its further copies:
C84, C86, C87, C88, C146, C148: 100nF,16V; C_0402_1005Metric
C85: 1uF,25V; C_0402_1005Metric
D40: RCLAMP0524P; Diodes_UDFN-10_1.0x2.5mm_P0.5mm
J14: PHB2.0-02-20PWZ
NT22: NetTie_2; NetTie_SMD_5mil
R87, R98: 10K,1%; R_0402_1005Metric
R89, R90, R91, R92, R93, R94: 100R,1%,250mW; R_0603_1608Metric
R95: 1K,1%; R_0402_1005Metric
TP2, TP5, TP7, TP9, TP11, TP13, TP15, TP17, TP19, TP37: test_point_0.5mm
U42, U43: MS2575T; TSSOP-16_4.4x5mm_P0.65mm
U44: TXB0104RUTR; UQFN-12_1.7x2_Pitch0.4mm
U57: MT9700; SOT-23-5

Connections of its further copies:
+3.3V: C84.1, C86.1, C87.1, R95.1, U42.4 (EN), U42.16 (VCC), U43.4 (EN), U43.16 (VCC), U44.1 (VCCA), U44.12 (OE); also elsewhere on the board
+5V: C88.1, C146.1, R98.2, U44.11 (VCCB), U57.5 (VIN); also elsewhere on the board
/ENCODER_CONN_B/A_N: J14.2, R89.1, U42.1 (1B)
/ENCODER_CONN_B/A_P: J14.1, R89.2, U42.2 (1A)
/ENCODER_CONN_B/B_N: J14.4, R90.1, U42.7 (2B)
/ENCODER_CONN_B/B_P: J14.3, R90.2, U42.6 (2A)
/ENCODER_CONN_B/ENC.A: TP15.1, U42.3 (1Y); also elsewhere on the board
/ENCODER_CONN_B/ENC.B: TP17.1, U42.5 (2Y); also elsewhere on the board
/ENCODER_CONN_B/ENC.CLK: TP37.1, U44.5 (A4); also elsewhere on the board
/ENCODER_CONN_B/ENC.CS: TP5.1, U44.3 (A2); also elsewhere on the board
/ENCODER_CONN_B/ENC.MISO: TP7.1, U44.2 (A1); also elsewhere on the board
/ENCODER_CONN_B/ENC.MOSI: TP2.1, U44.4 (A3); also elsewhere on the board
/ENCODER_CONN_B/ENC.PWR: U57.4 (EN); also elsewhere on the board
/ENCODER_CONN_B/ENC.U: TP9.1, U43.3 (1Y); also elsewhere on the board
/ENCODER_CONN_B/ENC.V: TP11.1, U43.5 (2Y); also elsewhere on the board
/ENCODER_CONN_B/ENC.W: TP13.1, U43.11 (3Y); also elsewhere on the board
/ENCODER_CONN_B/ENC.Z: TP19.1, U42.11 (3Y); also elsewhere on the board
/ENCODER_CONN_B/ENC_PWR: C148.2, J14.19, U57.1 (VOUT); also elsewhere on the board
/ENCODER_CONN_B/ENC_SPI_MISO: D40.1 (IO1), D40.10 (NC), J14.10, R98.1, U44.10 (B1)
/ENCODER_CONN_B/ENC_SPI_MOSI: D40.4 (IO3), D40.7 (NC), J14.8, U44.8 (B3)
/ENCODER_CONN_B/ENC_SPI_NSS: D40.2 (IO2), D40.9 (NC), J14.9, U44.9 (B2)
/ENCODER_CONN_B/ENC_SPI_SCK: D40.5 (IO4), D40.6 (NC), J14.7, U44.7 (B4)
/ENCODER_CONN_B/HALL_U_N: J14.14, R92.1, U43.1 (1B)
/ENCODER_CONN_B/HALL_U_P: J14.13, R92.2, U43.2 (1A)
/ENCODER_CONN_B/HALL_V_N: J14.16, R93.1, U43.7 (2B)
/ENCODER_CONN_B/HALL_V_P: J14.15, R93.2, U43.6 (2A)
/ENCODER_CONN_B/HALL_W_N: J14.18, R94.1, U43.9 (3B)
/ENCODER_CONN_B/HALL_W_P: J14.17, R94.2, U43.10 (3A)
/ENCODER_CONN_B/MOTOT_TMP_N: C85.2, J14.12, NT22.2
/ENCODER_CONN_B/Z_N: J14.6, R91.1, U42.9 (3B)
/ENCODER_CONN_B/Z_P: J14.5, R91.2, U42.10 (3A)
/MB_TEMP: C85.1, J14.11, R95.2; also elsewhere on the board
GND: C84.2, C86.2, C87.2, C88.2, C146.2, C148.1, D40.3 (GND), D40.8 (NC), J14.20, NT22.1, R87.1, U42.8 (GND), U42.12 (~EN), U43.8 (GND), U43.12 (~EN), U44.6 (GND), U57.2 (GND); also elsewhere on the board
unnamed: R87.2, U57.3 (SET)

Parts:
C29: 100nF,16V; C_0402_1005Metric
C30: 10uF,10V; C_0402_1005Metric
U11: MX25L12833FM2I-10G; SOIC-8_5.3x5.3mm_P1.27mm

Connections:
+3.3V: C29.1, C30.1, U11.8 (VCC); also elsewhere on the board
/HPM5E31_TOP/FLASH.CS0: U11.1 (CS#); also elsewhere on the board
/HPM5E31_TOP/FLASH.D0: U11.5 (SI/SIO0); also elsewhere on the board
/HPM5E31_TOP/FLASH.D1: U11.2 (SO/SIO1); also elsewhere on the board
/HPM5E31_TOP/FLASH.D2: U11.3 (WP#/SIO2); also elsewhere on the board
/HPM5E31_TOP/FLASH.D3: U11.7 (REST#/SIO3); also elsewhere on the board
/HPM5E31_TOP/FLASH.SCLK: U11.6 (SCLK); also elsewhere on the board
GND: C29.2, C30.2, U11.4 (GND); also elsewhere on the board

Parts:
C149: 1uF,100V; C_1206_3216Metric
C150, C151: 1uF,25V; C_0402_1005Metric
D41: DFR1G; D_SOD-123
D42, D43: 1N5819WS; D_SOD-323
Q13, Q15: CSD19532Q5B; PQFN-8-EP_6x5mm_P1.27mm_Generic
R96, R97: 5.1R,1%; R_0402_1005Metric
U58: EG2104; SOP-8_3.9x4.9mm_P1.27mm
U59: AMASS_XT30UPB-M_1x02_P5.0mm_Vertical

Connections:
+10V: C151.1, D41.2 (A), U58.1 (VCC); also elsewhere on the board
/BRAKE_RES/BRAKE_RES_EN: U58.3 (SD); also elsewhere on the board
GNDPWR: C149.2, C151.2, Q15.3 (S), U58.4 (GND), U59.1 (-); also elsewhere on the board
unnamed: C150.1, D41.1 (K), U58.8 (VB)
unnamed: D42.2 (A), Q13.2 (G), R96.2
unnamed: D42.1 (K), R96.1, U58.7 (HO)
unnamed: D43.2 (A), Q15.2 (G), R97.2
unnamed: D43.1 (K), R97.1, U58.5 (LO)
unnamed: C150.2, Q13.3 (S), Q15.1 (D), U58.6 (VS), U59.2 (+)
PE2: U58.2 (IN); also elsewhere on the board
VBUS: C149.1, Q13.1 (D); also elsewhere on the board

Parts:
C65, C70: 1uF,100V; C_1206_3216Metric
C66, C67, C71, C72, C73, C75: 1uF,25V; C_0402_1005Metric
C68, C78: 10uF,10V; C_0402_1005Metric
C69, C142, C143: 100nF,16V; C_0402_1005Metric
C74: 22nF,50V; C_0402_1005Metric
C76, C77: 2.2nF,50V; C_0402_1005Metric
D32, D36: DFR1G; D_SOD-123
D33, D34, D37, D38: 1N5819WS; D_SOD-323
D35: RCLAMP3324P; Diodes_UDFN-10_1.0x2.5mm_P0.5mm
J24: WAFER-GH1.25-4PLB; JST_SH_BM04B-SRSS-TB_1x04-1MP_P1.00mm_Vertical
NT17, NT18, NT19, NT20: NetTie_2; NetTie_SMD_5mil
Q14, Q16: NCE01ND03S; SOP-8_3.9x4.9mm_P1.27mm
R61, R62, R64, R65: 5.1R,1%; R_0402_1005Metric
R63, R66: 100mR,1%,1W; R_1206_3216Metric
R67, R68, R69, R70: 20K,1%; R_0402_1005Metric
R71, R72, R75, R76: 1K,1%; R_0402_1005Metric
R73, R74: 33R,1%; R_0402_1005Metric
R77, R78: 10K,1%; R_0402_1005Metric
U28: PY32F002BF15U; QFN-20-1EP_3x3mm_P0.4mm_EP1.65x1.65mm
U29, U32: EG2104; SOP-8_3.9x4.9mm_P1.27mm
U30, U33: ZX-HY2.0-2PWT
U31: RT9193-33GB-MS; SOT-23-5
U35: RS622XTDE8; DFN-8-1EP_2x2mm_P0.5mm_EP0.6x1.2mm
U36, U37: 74LVC1G08; SOT-353_SC-70-5

Connections:
+3.3_2: C68.2, C69.1, C75.1, C78.2, C142.1, C143.1, J24.1, R67.2, R68.2, U28.6 (VCC), U31.5 (VOUT), U35.8 (V+), U36.5 (VCC), U37.5 (VCC); also elsewhere on the board
+5V: C73.1, U31.1 (VIN), U31.3 (EN); also elsewhere on the board
+10V: C67.1, C72.1, D32.2 (A), D36.2 (A), U29.1 (VCC), U32.1 (VCC); also elsewhere on the board
/BREAK_MCU/BREAKA_CUR_N: NT20.1, R76.2
/BREAK_MCU/BREAKA_CUR_P: NT19.1, R72.2
/BREAK_MCU/BREAKB_CUR_N: NT18.1, R75.2
/BREAK_MCU/BREAKB_CUR_P: NT17.1, R71.2
/BREAK_MCU/PY32_EXADC3: D35.2 (IO2), D35.9 (NC), U28.19 (PA6)
/BREAK_MCU/PY32_EXADC4: D35.1 (IO1), D35.10 (NC), U28.20 (PA7)
/BREAK_MCU/PY32_PWM0: U28.14 (PA1), U32.2 (IN)
/BREAK_MCU/PY32_PWM1: U28.13 (PA0), U29.2 (IN)
/BREAK_MCU/PY32_SD0: U28.3 (PB7), U37.1
/BREAK_MCU/PY32_SD1: U28.2 (PC1), U36.1
/BREAK_MCU/PY32_SWCLK: J24.3, U28.15 (PA2/SWC)
/BREAK_MCU/PY32_SWDIO: J24.2, U28.5 (PB6/SWD)
/BREAK_MCU/PYADC_0: C76.1, R73.1, U28.11 (PB1)
/BREAK_MCU/PYADC_7: C77.1, R74.1, U28.12 (PB0)
/BREAK_MCU/SD0: U32.3 (SD), U37.4
/BREAK_MCU/SD1: U29.3 (SD), U36.4
/MA_TEMP: D35.4 (IO3), D35.7 (NC), U28.17 (PA4); also elsewhere on the board
/MB_TEMP: D35.5 (IO4), D35.6 (NC), U28.16 (PA3); also elsewhere on the board
/nBREAK: U28.18 (PA5), U36.2, U37.2; also elsewhere on the board
GND: C68.1, C69.2, C73.2, C74.2, C75.2, C76.2, C77.2, C78.1, C142.2, C143.2, D35.3 (GND), D35.8 (NC), J24.4, J24.MP (MountPin), R69.2, R70.2, U28.4 (VSS), U28.21 (PAD), U31.2 (GND), U35.4 (V-), U35.9 (PAD), U36.3 (GND), U37.3 (GND); also elsewhere on the board
GNDPWR: C65.1, C67.2, C70.1, C72.2, NT18.2, NT20.2, Q14.3 (S1), Q16.3 (S1), R63.1, R66.1, U29.4 (GND), U30.3 (PAD), U30.4 (PAD), U32.4 (GND), U33.3 (PAD), U33.4 (PAD); also elsewhere on the board
unnamed: C66.1, D32.1 (K), U29.8 (VB)
unnamed: D33.2 (A), Q14.2 (G2), R61.2
unnamed: D33.1 (K), R61.1, U29.7 (HO)
unnamed: D34.2 (A), Q14.4 (G1), R62.2
unnamed: D34.1 (K), R62.1, U29.5 (LO)
unnamed: C71.1, D36.1 (K), U32.8 (VB)
unnamed: D37.2 (A), Q16.2 (G2), R64.2
unnamed: D37.1 (K), R64.1, U32.7 (HO)
unnamed: D38.2 (A), Q16.4 (G1), R65.2
unnamed: D38.1 (K), R65.1, U32.5 (LO)
unnamed: NT17.2, R63.2, U30.2
unnamed: NT19.2, R66.2, U33.2
unnamed: C66.2, Q14.1 (S2), Q14.5 (D1), Q14.6 (D1), U29.6 (VS), U30.1
unnamed: C71.2, Q16.1 (S2), Q16.5 (D1), Q16.6 (D1), U32.6 (VS), U33.1
unnamed: C74.1, U31.4 (NC/BP)
unnamed: R67.1, R69.1, R71.1, U35.3 (+INB)
unnamed: R75.1, R78.1, U35.2 (-INB)
unnamed: R73.2, R78.2, U35.1 (OUTB)
unnamed: R68.1, R70.1, R72.1, U35.5 (+INB)
unnamed: R76.1, R77.1, U35.6 (-INB)
unnamed: R74.2, R77.2, U35.7 (OUTB)
PC8: U28.7 (PB5); also elsewhere on the board
PC9: U28.8 (PB4); also elsewhere on the board
PC11: U28.9 (PB3); also elsewhere on the board
PC12: U28.10 (PB2); also elsewhere on the board
PF29: U28.1 (PC0/NRST); also elsewhere on the board
VBUS: C65.2, C70.2, Q14.7 (D2), Q14.8 (D2), Q16.7 (D2), Q16.8 (D2); also elsewhere on the board

Notes on the sheet:
硬件STO

Schematic: TJA1042.kicad_sch

Parts:
C110, C111: 47pF,50V; C_0402_1005Metric
C112, C113: 100nF,16V; C_0402_1005Metric
J20: WAFER-GH1.25-2PWB; JST_GH_SM02B-GHS-TB_1x02-1MP_P1.25mm_Horizontal
L8: SDCW2012-2-102TF; L_CommonModeChoke_Coilcraft_0805USB
R126: 120R,1%; R_0603_1608Metric
TP33, TP35: test_point_0.5mm
U52: TJA1042TK/3; VSON-8-1EP_3x3mm_P0.65mm_EP1.6x2.4mm

Connections:
+3.3V: C113.1, U52.5 (VIO); also elsewhere on the board
+5V: C112.1, U52.3 (VCC); also elsewhere on the board
/HPM5E31_TOP/CAN3.RXD: TP35.1, U52.4 (RXD); also elsewhere on the board
/HPM5E31_TOP/CAN3.TXD: TP33.1, U52.1 (TXD); also elsewhere on the board
GND: C110.1, C111.2, C112.2, C113.2, J20.MP (MountPin), U52.2 (GND), U52.8 (STB), U52.9 (EP); also elsewhere on the board
unnamed: C111.1, J20.1, L8.2, R126.1
unnamed: C110.2, J20.2, L8.3, R126.2
unnamed: L8.4, U52.7 (CAN_H)
unnamed: L8.1, U52.6 (CAN_L)

Parts of its further copies:
C114, C115: 47pF,50V; C_0402_1005Metric
C116, C117: 100nF,16V; C_0402_1005Metric
J21: WAFER-GH1.25-2PWB; JST_GH_SM02B-GHS-TB_1x02-1MP_P1.25mm_Horizontal
L9: SDCW2012-2-102TF; L_CommonModeChoke_Coilcraft_0805USB
R127: 120R,1%; R_0603_1608Metric
TP34, TP36: test_point_0.5mm
U53: TJA1042TK/3; VSON-8-1EP_3x3mm_P0.65mm_EP1.6x2.4mm

Connections of its further copies:
+3.3V: C117.1, U53.5 (VIO); also elsewhere on the board
+5V: C116.1, U53.3 (VCC); also elsewhere on the board
/HPM5E31_TOP/CAN0.RXD: TP36.1, U53.4 (RXD); also elsewhere on the board
/HPM5E31_TOP/CAN0.TXD: TP34.1, U53.1 (TXD); also elsewhere on the board
GND: C114.1, C115.2, C116.2, C117.2, J21.MP (MountPin), U53.2 (GND), U53.8 (STB), U53.9 (EP); also elsewhere on the board
unnamed: C115.1, J21.1, L9.2, R127.1
unnamed: C114.2, J21.2, L9.3, R127.2
unnamed: L9.4, U53.7 (CAN_H)
unnamed: L9.1, U53.6 (CAN_L)

Schematic: POWER_SUPPLY.kicad_sch

Parts:
C9: 10uF,100V; CP_Radial_D5.0mm_P2.50mm
C10, C13, C27: 2.2nF,50V; C_0402_1005Metric
C11, C14, C17, C20: 10uF,10V; C_0402_1005Metric
C12: 47pF,50V; C_0402_1005Metric
C15: 100nF,50V; C_0603_1608Metric
C16, C18, C19: 22uF,25V; C_0805_2012Metric
C21, C22, C25, C26: 100nF,10V; C_0201_0603Metric
C23, C24: 1uF,25V; C_0402_1005Metric
C28: 100nF,16V; C_0402_1005Metric
C154: 4.7uF,25V; C_0805_2012Metric
D11: SMBJ54A; D_SMB
F1: JFC2410-1100TS; JFC2410
FB1, FB2: 600Ω@100MHz; L_0402_1005Metric
L1: 100uH,490mA; L_Changjiang_FNR4030S
L2: 1uH,5.6A; L_Changjiang_FNR252012S
L3: 22uH,540mA; L_1008_2520Metric
L4: 4.7uH,2.4A; L_Changjiang_FNR252012S
R14, R20: 10K,1%; R_0402_1005Metric
R15: 365K,1%; R_0402_1005Metric
R16, R18, R49, R54: 50K,1%; R_0402_1005Metric
R17, R23: 200K,0.5%; R_0201_0603Metric
R19: 178K,0.5%; R_0201_0603Metric
R22: 2.1k,1%; R_0402_1005Metric
R24: 11K,1%; R_0402_1005Metric
R25: 44.2K,0.5%; R_0201_0603Metric
R26: 0R,1%; R_0805_2012Metric
R27: 100K,1%; R_0402_1005Metric
R32: 33R,1%; R_0402_1005Metric
R37, R44: 1K,1%; R_0402_1005Metric
R137: 140K,1%; R_0402_1005Metric
R138: 20K,1%; R_0402_1005Metric
U4: LM5164DDAR; HSOP-8-1EP_3.9x4.9mm_P1.27mm_EP2.41x3.1mm
U5, U8: MP1605GTF-Z; SOT-563
U6: AMASS_XT60-M_1x02_P7.20mm_Vertical
U7: JW5026; SOT-23-6
U9: LP5907MFX-3.3/NOPB; SOT-23-5
U10: REF3030AIDBZR; SOT-23-3
U61: RS621PXF; SOT-23-5

Connections:
+1V2: C14.1, L2.2, R17.2, U5.6 (OUT); also elsewhere on the board
+3.3V: C20.1, L4.2, R14.1, R23.2, U8.6 (OUT); also elsewhere on the board
+5V: C11.1, C17.1, C18.1, C19.1, C21.1, FB1.1, L3.2, R24.2, U5.3 (VIN), U8.3 (VIN), U8.5 (EN); also elsewhere on the board
+5VA: C22.1, C23.1, C25.1, FB1.2, U9.1 (IN), U9.3 (EN), U10.1 (IN)
+10V: C13.2, C16.1, C154.1, L1.2, R15.1, R20.1, U7.5 (VIN); also elsewhere on the board
/POWER_SUPPLY/FB: C12.2, R15.2, R18.1, U4.5 (FB)
/POWER_SUPPLY/PG10V: R20.2, U4.6 (PGOOD), U7.4 (EN)
/POWER_SUPPLY/VBUS_F: C9.1, F1.2, R49.2, R137.2, U4.2 (VIN)
/POWER_SUPPLY/VBUS_SW: C10.2, L1.1, R27.1, U4.8 (SW)
GND: C11.2, C14.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, FB2.1, R19.1, R22.1, R25.2, R26.2, U5.2 (GND), U7.2 (GND), U8.2 (GND); also elsewhere on the board
GNDA: C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, FB2.2, R44.1, U9.2 (GND), U10.3 (GND), U61.2 (V-); also elsewhere on the board
GNDPWR: C9.2, C154.2, D11.2 (A), R16.2, R18.2, R26.1, R54.2, R138.1, U4.1 (GND), U4.9 (EP), U6.1 (-); also elsewhere on the board
unnamed: C12.1, C13.1, R27.2
unnamed: C10.1, U4.7 (BST)
unnamed: R137.1, R138.2, U4.3 (EN/UVLO)
unnamed: R16.1, U4.4 (RON)
unnamed: R14.2, U5.5 (EN)
unnamed: R17.1, R19.2, U5.1 (FB)
unnamed: L2.1, U5.4 (SW)
unnamed: C15.2, U7.1 (BST)
unnamed: R22.2, R24.1, U7.3 (FB)
unnamed: C15.1, L3.1, U7.6 (SW)
unnamed: R23.1, R25.1, U8.1 (FB)
unnamed: L4.1, U8.4 (SW)
unnamed: R44.2, R49.1, U61.3 (+IN)
unnamed: R37.2, R54.1, U61.4 (-IN)
unnamed: R32.1, R37.1, U61.1 (OUT)
PF27: C27.1, R32.2; also elsewhere on the board
VBUS: D11.1 (K), F1.1, U6.2 (+); also elsewhere on the board
VDDA: C24.1, C28.1, U9.5 (OUT), U61.5 (V+); also elsewhere on the board
VREF: C26.1, U10.2 (OUT); also elsewhere on the board

Notes on the sheet:
10V低压主电源
输入插座
MCU内核1.274V电源 1.27V [1.25V ... 1.29V]
RON_K = Vout * 2500 / Fsw_Khz = 10 * 2500 / 500 = 50
模拟供电&电压基准
UVLO 12V
系统3.3V电源 3.31V [3.26V ... 3.38V]
系统5V电源
母线电压采集

Schematic: HPM5E31_TOP.kicad_sch

Parts:
D1, D2: RCLAMP3324P; Diodes_UDFN-10_1.0x2.5mm_P0.5mm
D3: NCD0603G1; LED_0603_1608Metric
D4: NCD0603R1; LED_0603_1608Metric
D5: NCD0603B1; LED_0603_1608Metric
J1, J2: Conn_Coaxial; SMA_BAT_Wireless_BWSMA-KWE-Z001
J3: WAFER-ZH1.5-4PWB; ZH_SM04_1.50mm_Horizontal
J4: Conn_02x05_Odd_Even; IDC_SMD_P1.27mm_02x05
K1: DSHP02TSGET; SW_DIP_SPSTx02_Slide_KingTek_DSHP02TS_W7.62mm_P1.27mm
R1, R2, R6, R7, R8: 2K,1%; R_0402_1005Metric
R3, R4, R5, R134, R146, R184, R185: 10K,1%; R_0402_1005Metric

Connections:
+3.3V: J3.1, J4.1, K1.1 (PIN1), K1.2 (PIN2), R3.2, R4.2, R6.2, R7.2, R8.2, R134.2, R146.2, R184.2, R185.2; also elsewhere on the board
/HPM5E31_TOP/~RESET: D1.2 (IO2), D1.9 (NC), J4.10; also elsewhere on the board
GND: D1.3 (GND), D1.8 (NC), D2.3 (GND), D2.8 (NC), J1.2 (Ext), J2.2 (Ext), J3.4, J3.MP (MountPin), J4.3, J4.5, R5.2; also elsewhere on the board
unnamed: D3.2 (A), R6.1
unnamed: D4.2 (A), R7.1
unnamed: D5.2 (A), R8.1
unnamed: K1.3 (PIN3), R2.1
unnamed: K1.4 (PIN4), R1.1
PA0: D1.4 (IO3), D1.7 (NC), J3.3; also elsewhere on the board
PA1: D1.1 (IO1), D1.10 (NC), J3.2; also elsewhere on the board
PA2: R1.2; also elsewhere on the board
PA3: R2.2; also elsewhere on the board
PA4: D2.1 (IO1), D2.10 (NC), J4.6; also elsewhere on the board
PA5: D2.5 (IO4), D2.6 (NC), J4.8, R4.1; also elsewhere on the board
PA6: D2.4 (IO3), D2.7 (NC), J4.4, R5.1; also elsewhere on the board
PA7: D2.2 (IO2), D2.9 (NC), J4.2, R3.1; also elsewhere on the board
PA8: D1.5 (IO4), D1.6 (NC), J4.9, R134.1; also elsewhere on the board
PC2: D3.1 (K); also elsewhere on the board
PC3: D4.1 (K); also elsewhere on the board
PC11: R185.1; also elsewhere on the board
PC12: R184.1; also elsewhere on the board
PC18: D5.1 (K); also elsewhere on the board
PE4: J1.1 (In); also elsewhere on the board
PE5: J2.1 (In); also elsewhere on the board
PF29: R146.1; also elsewhere on the board

Notes on the sheet:
TRGM高速连接器
三色用户LED
UART0

Schematic: EMS_BUTTON.kicad_sch

Parts:
C141: 100nF,16V; C_0402_1005Metric
C155: 1uF,25V; C_0402_1005Metric
J23: WAFER-GH1.25-4PWB; JST_GH_SM04B-GHS-TB_1x04-1MP_P1.25mm_Horizontal
R131, R132, R133: 499,1%; R_0402_1005Metric
R136: 4.7K,1%; R_0402_1005Metric
R139: 0R,1%; R_0402_1005Metric
U54: TLP2362; SO-5-6_4.55x3.7mm_P1.27mm

Connections:
+3.3V: C141.1, R136.2, U54.6 (VCC); also elsewhere on the board
+5V: R131.2; also elsewhere on the board
/nBREAK: C155.1, R136.1, R139.2; also elsewhere on the board
GND: C141.2, C155.2, J23.MP (MountPin), R133.2, U54.4 (GND); also elsewhere on the board
unnamed: J23.1, R131.1
unnamed: J23.2, R132.1
unnamed: J23.3, U54.3
unnamed: J23.4, R133.1
unnamed: R132.2, U54.1
unnamed: R139.1, U54.5

Schematic: MCU_POWER.kicad_sch

Parts:
C118, C119, C120, C121, C124, C126, C128, C132, C134, C136, C139: 100nF,10V; C_0201_0603Metric
C122, C123, C125, C127, C131, C133, C137, C138: 10uF,10V; C_0402_1005Metric
C129, C130: 10pF,50V; C_0402_1005Metric
C135: 4.7uF,10V; C_0402_1005Metric
C140, C144: 100nF,16V; C_0402_1005Metric
FB3: 600Ω@100MHz; L_0402_1005Metric
J22: USB_B; USB_B_OST_USB-B1HSxx_Horizontal
R128, R129, R135: 10K,1%; R_0402_1005Metric
R130: 33R,1%; R_0402_1005Metric
U3: HPM5E31IGN1; BGA-196_14x14_12.0x12.0mm_P0.8mm
U55: ECMF02-2AMX6; ST_UQFN-6L_1.5x1.7mm_P0.5mm
X1: 24M,10ppm; Oscillator_SMD_Abracon_ASCO-4Pin_1.6x1.2mm

Connections:
+1V2: C118.1, C119.1, C120.1, C121.1, C122.1, C123.1, U3.F6 (VDD_SOC), U3.F9 (VDD_SOC), U3.G6 (VDD_SOC), U3.G9 (VDD_SOC), U3.H9 (VDD_SOC); also elsewhere on the board
+3.3V: C127.1, C128.1, R135.2, U3.N4 (VPMC), U3.P4 (VPMC); also elsewhere on the board
/HPM5E31_TOP/MCU_POWER/USB'_N: J22.2 (D-), U55.5 (D-)
/HPM5E31_TOP/MCU_POWER/USB'_P: J22.3 (D+), U55.6 (D+)
/HPM5E31_TOP/MCU_POWER/USB_N: U3.L13 (USB0_DN), U55.2 (D-)
/HPM5E31_TOP/MCU_POWER/USB_P: U3.L14 (USB0_DP), U55.1 (D+)
/HPM5E31_TOP/MCU_POWER/USB_VBUS: J22.1 (VBUS), R130.1
/HPM5E31_TOP/MCU_POWER/VANA: C124.1, C125.1, FB3.2, U3.J9 (VANA)
/HPM5E31_TOP/MCU_POWER/VDD_OTPCAP: C135.1, C136.1, U3.K8 (VDD_OTPCAP)
/HPM5E31_TOP/MCU_POWER/VDD_PHY0CAP: C133.1, C134.1, U3.J6 (VDD_PHY0CAP)
/HPM5E31_TOP/MCU_POWER/VDD_PHY1CAP: C131.1, C132.1, U3.H6 (VDD_PHY1CAP)
/HPM5E31_TOP/MCU_POWER/VDD_PMCCAP: C137.1, C138.1, C139.1, U3.K7 (VDD_PMCCAP)
/HPM5E31_TOP/MCU_POWER/XTALI: C130.1, U3.K14 (XTALI), X1.1 (X1)
/HPM5E31_TOP/MCU_POWER/XTALO: C129.2, U3.K13 (XTALO), X1.3 (X2)
/HPM5E31_TOP/~RESET: C144.1, R135.1, U3.M3 (RSTN); also elsewhere on the board
GND: C118.2, C119.2, C120.2, C121.2, C122.2, C123.2, C127.2, C128.2, C129.1, C130.2, C131.2, C132.2, C133.2, C134.2, C135.2, C136.2, C137.2, C138.2, C139.2, C140.2, C144.2, J22.4 (GND), J22.5 (Shield), R128.1, R129.1, U3.A1 (VSS), U3.A14 (VSS), U3.E5 (VSS), U3.E10 (VSS), U3.F7 (VSS), U3.F8 (VSS), U3.G7 (VSS), U3.G8 (VSS), U3.H7 (VSS), U3.J7 (VSS), U3.K5 (VSS), U3.K10 (VSS), U3.N1 (DCDC_GND), U3.N3 (VSS), U3.P1 (VSS), U3.P2 (DCDC_GND), U3.P14 (VSS), U55.3 (GND), X1.2 (GND), X1.4 (GND); also elsewhere on the board
GNDA: C124.2, C125.2, C126.2, U3.H8 (VSSA), U3.J8 (VREFL); also elsewhere on the board
unnamed: R128.2, U3.M1 (DCDC_IN), U3.M2 (DCDC_IN)
unnamed: R129.2, U3.N2 (DCDC_LP), U3.P3 (DCDC_LP)
unnamed: C140.1, R130.2, U3.L12 (USB0_VBUS)
VDDA: FB3.1; also elsewhere on the board
VREF: C126.1, U3.K9 (VREFH); also elsewhere on the board

Schematic: HPM5E31_PORTE.kicad_sch

Parts:
U3: HPM5E31IGN1; BGA-196_14x14_12.0x12.0mm_P0.8mm

Connections:
/ETHERNET_PHY_P2/MII.LINK: U3.N14 (PE03/GPTMR1.CAPT1/UART0.CTS/I2C2.SDA/MC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); also elsewhere on the board
/HPM5E31_TOP/DRIVER_B.EN: U3.M14 (PE00/GPTMR1.COMP0/UART0.TXD/MCAN0.TXD/E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); also elsewhere on the board
PE1: U3.M13 (PE01/GPTMR1.CAPT0/UART0.RXD/MCAN0.RXD/E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)
PE2: U3.M12 (PE02/GPTMR1.COMP1/UART0.DE/UART0.RTS/I2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); also elsewhere on the board
PE4: U3.N13 (PE04/UART1.CTS/MCAN1.RXD/ESC0.CTR2/PWM0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); also elsewhere on the board
PE5: U3.P13 (PE05/GPTMR1.COMP2/UART1.DE/UART1.RTS/MC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); also elsewhere on the board

Schematic: HPM5E31_PINMAP_1.kicad_sch

Parts:
R9: 33R,1%; R_0201_0603Metric
R10, R11: 4.7K,1%; R_0402_1005Metric
TP20: test_point_0.5mm

Connections:
+3.3V: R10.1, R11.1; also elsewhere on the board
/ETHERNET_PHY_P2/MII.MDC: R11.2; also elsewhere on the board
/ETHERNET_PHY_P2/MII.MDIO: R10.2; also elsewhere on the board
/ETHERNET_PHY_P2/MII.REFCLK: R9.1; also elsewhere on the board
/ETHERNET_PHY_P2/MII.RST: TP20.1; also elsewhere on the board
PA9: R9.2; also elsewhere on the board

Notes on the sheet:
UART3
ADC_CH5
ADC_CH12
SPI2
CTR4
ADC_CH14
CTR5
CAN0
ADC_CH3
UART6
ADC_CH7
QEI1
CAN3
ADC_CH1
CTR1
ADC_CH11
QEI0
ADC_CH8
SPI3
SPI1
UART4

Schematic: HPM5E31_PINMAP_2.kicad_sch

Parts:
C1, C2, C3, C4: 100nF,16V; C_0402_1005Metric
D6, D7, D9: RCLAMP0524P; Diodes_UDFN-10_1.0x2.5mm_P0.5mm
D8: NCD0603G1; LED_0603_1608Metric
D10: NCD0603R1; LED_0603_1608Metric
J5: WAFER-GH1.25-6PWB; JST_GH_SM06B-GHS-TB_1x06-1MP_P1.25mm_Horizontal
J6: Conn_02x05_Odd_Even; IDC_SMD_P1.27mm_02x05
R12, R13: 2K,1%; R_0402_1005Metric
U1: TXS0108ERGYR; Texas_RGY_R-PVQFN-N20_EP2.05x3.05mm
U2: TXB0104RUTR; UQFN-12_1.7x2_Pitch0.4mm

Connections:
+3.3V: C1.1, C3.1, R12.2, R13.2, U1.2 (VCCA), U1.10 (OE), U2.1 (VCCA), U2.12 (OE); also elsewhere on the board
+5V: C2.1, C4.1, J5.5, J6.1, U1.19 (VCCB), U2.11 (VCCB); also elsewhere on the board
/HPM5E31_TOP/HPM5E31_PINMAP_2/ESC_GPIO_0: D7.1 (IO1), D7.10 (NC), J6.8, U1.18 (B2)
/HPM5E31_TOP/HPM5E31_PINMAP_2/ESC_GPIO_1: D7.2 (IO2), D7.9 (NC), J6.6, U1.17 (B3)
/HPM5E31_TOP/HPM5E31_PINMAP_2/ESC_GPIO_2: D7.4 (IO3), D7.7 (NC), J6.4, U1.16 (B4)
/HPM5E31_TOP/HPM5E31_PINMAP_2/ESC_GPIO_3: D9.1 (IO1), D9.10 (NC), J6.7, U1.15 (B5)
/HPM5E31_TOP/HPM5E31_PINMAP_2/ESC_GPIO_4: D9.2 (IO2), D9.9 (NC), J6.5, U1.14 (B6)
/HPM5E31_TOP/HPM5E31_PINMAP_2/ESC_GPIO_5: D9.4 (IO3), D9.7 (NC), J6.3, U1.13 (B7)
/HPM5E31_TOP/HPM5E31_PINMAP_2/EUI_CK: D6.4 (IO3), D6.7 (NC), J5.2, U2.8 (B3)
/HPM5E31_TOP/HPM5E31_PINMAP_2/EUI_DI: D6.1 (IO1), D6.10 (NC), J5.4, U2.10 (B1)
/HPM5E31_TOP/HPM5E31_PINMAP_2/EUI_DO: D6.2 (IO2), D6.9 (NC), J5.3, U2.9 (B2)
/HPM5E31_TOP/HPM5E31_PINMAP_2/EUI_SH: D6.5 (IO4), D6.6 (NC), J5.1, U2.7 (B4)
GND: C1.2, C2.2, C3.2, C4.2, D6.3 (GND), D6.8 (NC), D7.3 (GND), D7.8 (NC), D9.3 (GND), D9.8 (NC), J5.6, J5.MP (MountPin), J6.9, J6.10, U1.11 (GND), U1.21 (PAD), U2.6 (GND); also elsewhere on the board
unnamed: D8.2 (A), R12.1
unnamed: D10.2 (A), R13.1
PB26: U2.4 (A3); also elsewhere on the board
PB27: U2.5 (A4); also elsewhere on the board
PB28: U2.2 (A1); also elsewhere on the board
PB29: U2.3 (A2); also elsewhere on the board
PB30: D8.1 (K); also elsewhere on the board
PB31: D10.1 (K); also elsewhere on the board
PC17: U1.8 (A7); also elsewhere on the board
PD1: U1.7 (A6); also elsewhere on the board
PD2: U1.6 (A5); also elsewhere on the board
PD3: U1.5 (A4); also elsewhere on the board
PD4: U1.4 (A3); also elsewhere on the board
PD9: U1.3 (A2); also elsewhere on the board

Notes on the sheet:
EUI1
ESC错误LED
ESC_IO
ESC运行LED

Schematic: HPM5E31_PORTF.kicad_sch

Parts:
U3: HPM5E31IGN1; BGA-196_14x14_12.0x12.0mm_P0.8mm

Connections:
/HPM5E31_TOP/DRIVER_A.CUR0: U3.N5 (PF31/SDM0.CLK3/ADC0.IN07/ADC1.IN07/ACMP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); also elsewhere on the board
/HPM5E31_TOP/DRIVER_A.CUR1: U3.P5 (PF28/SDM0.DAT3/ADC0.IN05/ADC1.IN05/ACMP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); also elsewhere on the board
/HPM5E31_TOP/DRIVER_A.CUR2: U3.N6 (PF20/SDM0.DAT3/USB0.OC/ETH0.EVTO1/ESC0.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); also elsewhere on the board
/HPM5E31_TOP/DRIVER_A.CUR3: U3.P6 (PF26/SDM0.DAT1/ADC0.IN01/ADC1.IN01/ACMP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); also elsewhere on the board
/HPM5E31_TOP/DRIVER_A.EN: U3.P12 (PF06/I2C3.SDA/ESC0.P1_TXD3/PWM0.P6/TRGM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); also elsewhere on the board
/HPM5E31_TOP/DRIVER_A.HI0: U3.N10 (PF00/MCAN0.TXD/ESC0.MDC/PWM0.P0/TRGM.P0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); also elsewhere on the board
/HPM5E31_TOP/DRIVER_A.HI1: U3.P11 (PF02/I2C2.SCL/MCAN0.STBY/ESC0.P1_TXCK/P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); also elsewhere on the board
/HPM5E31_TOP/DRIVER_A.HI2: U3.M8 (PF04/MCAN1.RXD/ESC0.P1_TXD1/PWM0.P4/TRG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); also elsewhere on the board
/HPM5E31_TOP/DRIVER_A.LI0: U3.L10 (PF01/MCAN0.RXD/ESC0.MDIO/PWM0.P1/TRGM.P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); also elsewhere on the board
/HPM5E31_TOP/DRIVER_A.LI1: U3.M9 (PF03/I2C2.SDA/MCAN1.STBY/ESC0.P1_TXD0/P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); also elsewhere on the board
/HPM5E31_TOP/DRIVER_A.LI2: U3.L8 (PF05/MCAN1.TXD/ESC0.P1_TXD2/PWM0.P5/TRG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); also elsewhere on the board
/HPM5E31_TOP/DRIVER_B.CUR0: U3.P8 (PF18/SDM0.DAT1/USB0.PWR/ETH0.EVTO0/ESC0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); also elsewhere on the board
/HPM5E31_TOP/DRIVER_B.CUR1: U3.N8 (PF22/SDM0.CLK2/USB0.ID/ETH0.EVTI1/ESC0.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); also elsewhere on the board
/HPM5E31_TOP/DRIVER_B.CUR2: U3.P7 (PF17/SDM0.CLK0/ADC0.IN12/ADC1.IN12/ACMP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); also elsewhere on the board
/HPM5E31_TOP/DRIVER_B.CUR3: U3.N7 (PF16/SDM0.DAT0/ADC0.IN08/ADC1.IN08/ACMP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); also elsewhere on the board
/HPM5E31_TOP/DRIVER_B.HI0: U3.L11 (PF08/I2C0.SCL/MCAN2.TXD/ESC0.P1_RXDV/PW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); also elsewhere on the board
/HPM5E31_TOP/DRIVER_B.HI1: U3.P10 (PF10/MCAN2.STBY/ESC0.P1_RXD1/PWM1.P2/TR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); also elsewhere on the board
/HPM5E31_TOP/DRIVER_B.HI2: U3.N11 (PF12/I2C1.SDA/ESC0.P1_RXD3/PWM1.P4/TRGM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); also elsewhere on the board
/HPM5E31_TOP/DRIVER_B.LI0: U3.M10 (PF09/I2C0.SDA/MCAN2.RXD/ESC0.P1_RXD0/PW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); also elsewhere on the board
/HPM5E31_TOP/DRIVER_B.LI1: U3.L9 (PF11/ESC0.P1_RXD2/PWM1.P3/TRGM.P11/ETH0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); also elsewhere on the board
/HPM5E31_TOP/DRIVER_B.LI2: U3.N12 (PF13/I2C1.SCL/MCAN3.STBY/ESC0.P1_RXCK/P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); also elsewhere on the board
PF7: U3.M11 (PF07/I2C3.SCL/ESC0.P1_TXEN/PWM0.P7/TRGM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)
PF14: U3.N9 (PF14/MCAN3.RXD/ESC0.P1_RXER/PWM1.P6/TRG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)
PF15: U3.P9 (PF15/MCAN3.TXD/PWM1.P7/TRGM.P15/ETH0.TX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)
PF19: U3.M5 (PF19/SDM0.CLK1/USB0.PWR/ADC0.IN13/ADC1.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); also elsewhere on the board
PF21: U3.L6 (PF21/SDM0.DAT2/USB0.ID/ETH0.EVTI0/ESC0.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)
PF23: U3.L5 (PF23/SDM0.CLK3/USB0.OC/ADC0.IN15/ADC1.I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)
PF24: U3.M6 (PF24/SDM0.DAT0/ADC0.IN10/ADC1.IN10/ACMP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); also elsewhere on the board
PF25: U3.L7 (PF25/SDM0.CLK0/ADC0.IN09/ADC1.IN09/ACMP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)
PF27: U3.M7 (PF27/SDM0.CLK1/ADC0.IN00/ADC1.IN00/ACMP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); also elsewhere on the board
PF29: U3.M4 (PF29/SDM0.DAT2/ADC0.IN04/ADC1.IN04/ACMP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); also elsewhere on the board
PF30: U3.L4 (PF30/SDM0.CLK2/ADC0.IN06/ADC1.IN06/ACMP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)
